# Keil uVision project test.uvprojx, settings and files
target startup (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ../pr/: main.c
    ../pr/RTE/Device/MDR1986BE92/: MDR32F9Qx_config.h startup_MDR32F9Qx.s system_MDR32F9Qx.c system_MDR32F9Qx.h
    C:/Keil_v5/ARM/Packs/Keil/MDR1986xx/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.h
