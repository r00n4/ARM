# Keil uVision project USB_MSC.uvprojx, settings and files
target MDR32F9Qx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USB_MSC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\git\ARM\USB_MSD\norm\RTE\Device\MDR1986BE92; C:\git\ARM\Files
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User_Code
    ./: main.c
software components: CMSIS Driver:USB Device:Custom 2.2.0, CMSIS:CORE 5.3.0, CMSIS:RTOS2:Keil RTX5 5.5.1, USB:CORE 6.13.7, USB:Device 6.13.7, USB:Device:MSC 6.13.7, Device:Startup 1.5, Drivers:USB Library 1.5, Drivers:USB 1.5
