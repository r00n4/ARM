# Keil uVision project Memory.uvproj, settings and files
target MCBSTM32 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Memory
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Code
    ./: STM32F10x.s
  group Initialisation
    ./: STM32_Init.c
  group Configuration
    ./: usbcfg.h
  group Disk Image
    ./: DiskImg.c
  group Source Code
    ./: usbcore.c usbdesc.c usbhw.c usbuser.c mscuser.c LCD_4bit.c memory.c
  group Documentation
    ./: Abstract.txt
